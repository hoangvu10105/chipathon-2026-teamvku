VERSION 5.7 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

SITE GF_IO_Site
  CLASS PAD ;
  SIZE 1.000 BY 350.000 ;
  SYMMETRY X Y R90 ;
END GF_IO_Site

SITE GF_COR_Site
  CLASS PAD ;
  SIZE 355.000 BY 355.000 ;
  SYMMETRY X Y R90 ;
END GF_COR_Site

END LIBRARY
